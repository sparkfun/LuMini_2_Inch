# Repository sparkfun/LuMini_2_Inch (continued)

## EAGLE design Production/14074-LuMini_2Inch-panel.brd

Board: 2 copper layers, 122.4 x 231.6 mm, 571 parts (168 on the bottom side), 672 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: DNP; 1206
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129, D130, D131, D132, D133, D134, D135, D136, D137, D138, D139, D140, D141, D142, D143, D144, D145, D146, D147, D148, D149, D150, D151, D152, D153, D154, D155, D156, D157, D158, D159, D160, D161, D162, D163, D164, D165, D166, D167, D168, D169, D170, D171, D172, D173, D174, D175, D176, D177, D178, D179, D180, D181, D182, D183, D184, D185, D186, D187, D188, D189, D190, D191, D192, D193, D194, D195, D196, D197, D198, D199, D200, D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212, D213, D214, D215, D216, D217, D218, D219, D220, D221, D222, D223, D224, D225, D226, D227, D228, D229, D230, D231, D232, D233, D234, D235, D236, D237, D238, D239, D240, D241, D242, D243, D244, D245, D246, D247, D248, D249, D250, D251, D252, D253, D254, D255, D256, D257, D258, D259, D260, D261, D262, D263, D264, D265, D266, D267, D268, D269, D270, D271, D272, D273, D274, D275, D276, D277, D278, D279, D280, D281, D282, D283, D284, D285, D286, D287, D288, D289, D290, D291, D292, D293, D294, D295, D296, D297, D298, D299, D300, D301, D302, D303, D304, D305, D306, D307, D308, D309, D310, D311, D312, D313, D314, D315, D316, D317, D318, D319, D320: APA102-2020
E$1: FIDUCIAL-1.5X3
E$5, E$6: FIDUCIAL-1X2
FD1, FD2, FD3, FD4, FD5, FD6, FD7, FD8, FD9, FD10, FD11, FD12, FD13, FD14, FD15, FD16, FD17, FD18, FD19, FD20, FD21, FD22, FD23, FD24, FD25, FD26, FD27, FD28, FD29, FD30, FD31, FD32: FIDUCIALUFIDUCIAL; FIDUCIAL-MICRO
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18, H19, H20, H21, H22, H23, H24, H25, H26, H27, H28, H29, H30, H31, H32, H33, H34, H35, H36, H37, H38, H39, H40, H41, H42, H43, H44, H45, H46, H47, H48, H49, H50, H51, H52, H53, H54, H55, H56, H57, H58, H59, H60, H61, H62, H63, H64: STANDOFF_ELECTRICAL-NOTHERMALS; STANDOFF-ELECTRICAL-NOTHERMALS
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24: SOLDER_PAD_2
LOGO1, LOGO3, LOGO5, LOGO7, LOGO9, LOGO11, LOGO13, LOGO15: OSHW-LOGOS; OSHW-LOGO-S
LOGO2, LOGO4, LOGO6, LOGO8, LOGO10, LOGO12, LOGO14, LOGO16: SFE_LOGO_NAME.1_INCH; SFE_LOGO_NAME_.1
U$1, U$14, U$27, U$40, U$53, U$66, U$79, U$92: LUMINI_2#0
U$2, U$22, U$35, U$48, U$61, U$74, U$87, U$100: 54
U$3, U$23, U$36, U$49, U$62, U$75, U$88, U$101: 156
U$4, U$15, U$28, U$41, U$54, U$67, U$80, U$93: 5V6
U$5, U$16, U$29, U$42, U$55, U$68, U$81, U$94: G4
U$6, U$24, U$37, U$50, U$63, U$76, U$89, U$102: 194
U$7, U$17, U$30, U$43, U$56, U$69, U$82, U$95: DO3
U$8, U$18, U$31, U$44, U$57, U$70, U$83, U$96: CO1
U$9, U$19, U$32, U$45, U$58, U$71, U$84, U$97: CI6
U$10, U$20, U$33, U$46, U$59, U$72, U$85, U$98: DI4
U$11, U$21, U$34, U$47, U$60, U$73, U$86, U$99: 40_APA102_LED#S1
U$12, U$25, U$38, U$51, U$64, U$77, U$90, U$103: 258
U$13, U$26, U$39, U$52, U$65, U$78, U$91, U$104: 3510

Connections:
5V: C1.1, D1.VDD, D2.VDD, D3.VDD, D4.VDD, D5.VDD, D6.VDD, D7.VDD, D8.VDD, D9.VDD, D10.VDD, D11.VDD, D12.VDD, D13.VDD, D14.VDD, D15.VDD, D16.VDD, D17.VDD, D18.VDD, D19.VDD, D20.VDD, D21.VDD, D22.VDD, D23.VDD, D24.VDD, D25.VDD, D26.VDD, D27.VDD, D28.VDD, D29.VDD, D30.VDD, D31.VDD, D32.VDD, D33.VDD, D34.VDD, D35.VDD, D36.VDD, D37.VDD, D38.VDD, D39.VDD, D40.VDD, J1.P$2
5V1: C2.1, D41.VDD, D42.VDD, D43.VDD, D44.VDD, D45.VDD, D46.VDD, D47.VDD, D48.VDD, D49.VDD, D50.VDD, D51.VDD, D52.VDD, D53.VDD, D54.VDD, D55.VDD, D56.VDD, D57.VDD, D58.VDD, D59.VDD, D60.VDD, D61.VDD, D62.VDD, D63.VDD, D64.VDD, D65.VDD, D66.VDD, D67.VDD, D68.VDD, D69.VDD, D70.VDD, D71.VDD, D72.VDD, D73.VDD, D74.VDD, D75.VDD, D76.VDD, D77.VDD, D78.VDD, D79.VDD, D80.VDD, J4.P$2
5V2: C3.1, D81.VDD, D82.VDD, D83.VDD, D84.VDD, D85.VDD, D86.VDD, D87.VDD, D88.VDD, D89.VDD, D90.VDD, D91.VDD, D92.VDD, D93.VDD, D94.VDD, D95.VDD, D96.VDD, D97.VDD, D98.VDD, D99.VDD, D100.VDD, D101.VDD, D102.VDD, D103.VDD, D104.VDD, D105.VDD, D106.VDD, D107.VDD, D108.VDD, D109.VDD, D110.VDD, D111.VDD, D112.VDD, D113.VDD, D114.VDD, D115.VDD, D116.VDD, D117.VDD, D118.VDD, D119.VDD, D120.VDD, J7.P$2
5V3: C4.1, D121.VDD, D122.VDD, D123.VDD, D124.VDD, D125.VDD, D126.VDD, D127.VDD, D128.VDD, D129.VDD, D130.VDD, D131.VDD, D132.VDD, D133.VDD, D134.VDD, D135.VDD, D136.VDD, D137.VDD, D138.VDD, D139.VDD, D140.VDD, D141.VDD, D142.VDD, D143.VDD, D144.VDD, D145.VDD, D146.VDD, D147.VDD, D148.VDD, D149.VDD, D150.VDD, D151.VDD, D152.VDD, D153.VDD, D154.VDD, D155.VDD, D156.VDD, D157.VDD, D158.VDD, D159.VDD, D160.VDD, J10.P$2
5V4: C5.1, D161.VDD, D162.VDD, D163.VDD, D164.VDD, D165.VDD, D166.VDD, D167.VDD, D168.VDD, D169.VDD, D170.VDD, D171.VDD, D172.VDD, D173.VDD, D174.VDD, D175.VDD, D176.VDD, D177.VDD, D178.VDD, D179.VDD, D180.VDD, D181.VDD, D182.VDD, D183.VDD, D184.VDD, D185.VDD, D186.VDD, D187.VDD, D188.VDD, D189.VDD, D190.VDD, D191.VDD, D192.VDD, D193.VDD, D194.VDD, D195.VDD, D196.VDD, D197.VDD, D198.VDD, D199.VDD, D200.VDD, J13.P$2
5V5: C6.1, D201.VDD, D202.VDD, D203.VDD, D204.VDD, D205.VDD, D206.VDD, D207.VDD, D208.VDD, D209.VDD, D210.VDD, D211.VDD, D212.VDD, D213.VDD, D214.VDD, D215.VDD, D216.VDD, D217.VDD, D218.VDD, D219.VDD, D220.VDD, D221.VDD, D222.VDD, D223.VDD, D224.VDD, D225.VDD, D226.VDD, D227.VDD, D228.VDD, D229.VDD, D230.VDD, D231.VDD, D232.VDD, D233.VDD, D234.VDD, D235.VDD, D236.VDD, D237.VDD, D238.VDD, D239.VDD, D240.VDD, J16.P$2
5V6: C7.1, D241.VDD, D242.VDD, D243.VDD, D244.VDD, D245.VDD, D246.VDD, D247.VDD, D248.VDD, D249.VDD, D250.VDD, D251.VDD, D252.VDD, D253.VDD, D254.VDD, D255.VDD, D256.VDD, D257.VDD, D258.VDD, D259.VDD, D260.VDD, D261.VDD, D262.VDD, D263.VDD, D264.VDD, D265.VDD, D266.VDD, D267.VDD, D268.VDD, D269.VDD, D270.VDD, D271.VDD, D272.VDD, D273.VDD, D274.VDD, D275.VDD, D276.VDD, D277.VDD, D278.VDD, D279.VDD, D280.VDD, J19.P$2
5V7: C8.1, D281.VDD, D282.VDD, D283.VDD, D284.VDD, D285.VDD, D286.VDD, D287.VDD, D288.VDD, D289.VDD, D290.VDD, D291.VDD, D292.VDD, D293.VDD, D294.VDD, D295.VDD, D296.VDD, D297.VDD, D298.VDD, D299.VDD, D300.VDD, D301.VDD, D302.VDD, D303.VDD, D304.VDD, D305.VDD, D306.VDD, D307.VDD, D308.VDD, D309.VDD, D310.VDD, D311.VDD, D312.VDD, D313.VDD, D314.VDD, D315.VDD, D316.VDD, D317.VDD, D318.VDD, D319.VDD, D320.VDD, J22.P$2
CI: D1.CKI, J2.P$2
CI1: D41.CKI, J5.P$2
CI2: D81.CKI, J8.P$2
CI3: D121.CKI, J11.P$2
CI4: D161.CKI, J14.P$2
CI5: D201.CKI, J17.P$2
CI6: D241.CKI, J20.P$2
CI7: D281.CKI, J23.P$2
CO: D40.CKO, J3.P$2
CO1: D80.CKO, J6.P$2
CO2: D120.CKO, J9.P$2
CO3: D160.CKO, J12.P$2
CO4: D200.CKO, J15.P$2
CO5: D240.CKO, J18.P$2
CO6: D280.CKO, J21.P$2
CO7: D320.CKO, J24.P$2
DI: D1.SDI, J2.P$1
DI1: D41.SDI, J5.P$1
DI2: D81.SDI, J8.P$1
DI3: D121.SDI, J11.P$1
DI4: D161.SDI, J14.P$1
DI5: D201.SDI, J17.P$1
DI6: D241.SDI, J20.P$1
DI7: D281.SDI, J23.P$1
DO: D40.SDO, J3.P$1
DO1: D80.SDO, J6.P$1
DO2: D120.SDO, J9.P$1
DO3: D160.SDO, J12.P$1
DO4: D200.SDO, J15.P$1
DO5: D240.SDO, J18.P$1
DO6: D280.SDO, J21.P$1
DO7: D320.SDO, J24.P$1
GND: C1.2, D1.GND, D2.GND, D3.GND, D4.GND, D5.GND, D6.GND, D7.GND, D8.GND, D9.GND, D10.GND, D11.GND, D12.GND, D13.GND, D14.GND, D15.GND, D16.GND, D17.GND, D18.GND, D19.GND, D20.GND, D21.GND, D22.GND, D23.GND, D24.GND, D25.GND, D26.GND, D27.GND, D28.GND, D29.GND, D30.GND, D31.GND, D32.GND, D33.GND, D34.GND, D35.GND, D36.GND, D37.GND, D38.GND, D39.GND, D40.GND, H1.P1, H2.P1, H3.P1, H4.P1, H5.P1, H6.P1, H7.P1, H8.P1, J1.P$1
GND1: C2.2, D41.GND, D42.GND, D43.GND, D44.GND, D45.GND, D46.GND, D47.GND, D48.GND, D49.GND, D50.GND, D51.GND, D52.GND, D53.GND, D54.GND, D55.GND, D56.GND, D57.GND, D58.GND, D59.GND, D60.GND, D61.GND, D62.GND, D63.GND, D64.GND, D65.GND, D66.GND, D67.GND, D68.GND, D69.GND, D70.GND, D71.GND, D72.GND, D73.GND, D74.GND, D75.GND, D76.GND, D77.GND, D78.GND, D79.GND, D80.GND, H9.P1, H10.P1, H11.P1, H12.P1, H13.P1, H14.P1, H15.P1, H16.P1, J4.P$1
GND2: C3.2, D81.GND, D82.GND, D83.GND, D84.GND, D85.GND, D86.GND, D87.GND, D88.GND, D89.GND, D90.GND, D91.GND, D92.GND, D93.GND, D94.GND, D95.GND, D96.GND, D97.GND, D98.GND, D99.GND, D100.GND, D101.GND, D102.GND, D103.GND, D104.GND, D105.GND, D106.GND, D107.GND, D108.GND, D109.GND, D110.GND, D111.GND, D112.GND, D113.GND, D114.GND, D115.GND, D116.GND, D117.GND, D118.GND, D119.GND, D120.GND, H17.P1, H18.P1, H19.P1, H20.P1, H21.P1, H22.P1, H23.P1, H24.P1, J7.P$1
GND3: C4.2, D121.GND, D122.GND, D123.GND, D124.GND, D125.GND, D126.GND, D127.GND, D128.GND, D129.GND, D130.GND, D131.GND, D132.GND, D133.GND, D134.GND, D135.GND, D136.GND, D137.GND, D138.GND, D139.GND, D140.GND, D141.GND, D142.GND, D143.GND, D144.GND, D145.GND, D146.GND, D147.GND, D148.GND, D149.GND, D150.GND, D151.GND, D152.GND, D153.GND, D154.GND, D155.GND, D156.GND, D157.GND, D158.GND, D159.GND, D160.GND, H25.P1, H26.P1, H27.P1, H28.P1, H29.P1, H30.P1, H31.P1, H32.P1, J10.P$1
GND4: C5.2, D161.GND, D162.GND, D163.GND, D164.GND, D165.GND, D166.GND, D167.GND, D168.GND, D169.GND, D170.GND, D171.GND, D172.GND, D173.GND, D174.GND, D175.GND, D176.GND, D177.GND, D178.GND, D179.GND, D180.GND, D181.GND, D182.GND, D183.GND, D184.GND, D185.GND, D186.GND, D187.GND, D188.GND, D189.GND, D190.GND, D191.GND, D192.GND, D193.GND, D194.GND, D195.GND, D196.GND, D197.GND, D198.GND, D199.GND, D200.GND, H33.P1, H34.P1, H35.P1, H36.P1, H37.P1, H38.P1, H39.P1, H40.P1, J13.P$1
GND5: C6.2, D201.GND, D202.GND, D203.GND, D204.GND, D205.GND, D206.GND, D207.GND, D208.GND, D209.GND, D210.GND, D211.GND, D212.GND, D213.GND, D214.GND, D215.GND, D216.GND, D217.GND, D218.GND, D219.GND, D220.GND, D221.GND, D222.GND, D223.GND, D224.GND, D225.GND, D226.GND, D227.GND, D228.GND, D229.GND, D230.GND, D231.GND, D232.GND, D233.GND, D234.GND, D235.GND, D236.GND, D237.GND, D238.GND, D239.GND, D240.GND, H41.P1, H42.P1, H43.P1, H44.P1, H45.P1, H46.P1, H47.P1, H48.P1, J16.P$1
GND6: C7.2, D241.GND, D242.GND, D243.GND, D244.GND, D245.GND, D246.GND, D247.GND, D248.GND, D249.GND, D250.GND, D251.GND, D252.GND, D253.GND, D254.GND, D255.GND, D256.GND, D257.GND, D258.GND, D259.GND, D260.GND, D261.GND, D262.GND, D263.GND, D264.GND, D265.GND, D266.GND, D267.GND, D268.GND, D269.GND, D270.GND, D271.GND, D272.GND, D273.GND, D274.GND, D275.GND, D276.GND, D277.GND, D278.GND, D279.GND, D280.GND, H49.P1, H50.P1, H51.P1, H52.P1, H53.P1, H54.P1, H55.P1, H56.P1, J19.P$1
GND7: C8.2, D281.GND, D282.GND, D283.GND, D284.GND, D285.GND, D286.GND, D287.GND, D288.GND, D289.GND, D290.GND, D291.GND, D292.GND, D293.GND, D294.GND, D295.GND, D296.GND, D297.GND, D298.GND, D299.GND, D300.GND, D301.GND, D302.GND, D303.GND, D304.GND, D305.GND, D306.GND, D307.GND, D308.GND, D309.GND, D310.GND, D311.GND, D312.GND, D313.GND, D314.GND, D315.GND, D316.GND, D317.GND, D318.GND, D319.GND, D320.GND, H57.P1, H58.P1, H59.P1, H60.P1, H61.P1, H62.P1, H63.P1, H64.P1, J22.P$1
unnamed: D4.CKO, D5.CKI
unnamed: D41.CKO, D51.CKI
unnamed: D41.SDO, D51.SDI
unnamed: D1.CKO, D2.CKI
unnamed: D1.SDO, D2.SDI
unnamed: D2.CKO, D3.CKI
unnamed: D2.SDO, D3.SDI
unnamed: D3.CKO, D4.CKI
unnamed: D3.SDO, D4.SDI
unnamed: D4.SDO, D5.SDI
unnamed: D5.CKO, D6.CKI
unnamed: D5.SDO, D6.SDI
unnamed: D6.CKO, D7.CKI
unnamed: D6.SDO, D7.SDI
unnamed: D7.CKO, D8.CKI
unnamed: D7.SDO, D8.SDI
unnamed: D24.CKO, D25.CKI
unnamed: D51.CKO, D52.CKI
unnamed: D9.CKO, D10.CKI
unnamed: D9.SDO, D10.SDI
unnamed: D10.CKO, D11.CKI
unnamed: D10.SDO, D11.SDI
unnamed: D11.CKO, D12.CKI
unnamed: D11.SDO, D12.SDI
unnamed: D12.CKO, D13.CKI
unnamed: D12.SDO, D13.SDI
unnamed: D13.CKO, D14.CKI
unnamed: D13.SDO, D14.SDI
unnamed: D14.CKO, D15.CKI
unnamed: D14.SDO, D15.SDI
unnamed: D15.CKO, D16.CKI
unnamed: D15.SDO, D16.SDI
unnamed: D51.SDO, D52.SDI
unnamed: D52.CKO, D53.CKI
unnamed: D17.CKO, D18.CKI
unnamed: D17.SDO, D18.SDI
unnamed: D18.CKO, D19.CKI
unnamed: D18.SDO, D19.SDI
unnamed: D19.CKO, D20.CKI
unnamed: D19.SDO, D20.SDI
unnamed: D20.CKO, D21.CKI
unnamed: D20.SDO, D21.SDI
unnamed: D16.SDO, D17.SDI
unnamed: D16.CKO, D17.CKI
unnamed: D8.SDO, D9.SDI
unnamed: D52.SDO, D53.SDI
unnamed: D24.SDO, D25.SDI
unnamed: D21.CKO, D22.CKI
unnamed: D21.SDO, D22.SDI
unnamed: D22.CKO, D23.CKI
unnamed: D22.SDO, D23.SDI
unnamed: D23.CKO, D24.CKI
unnamed: D23.SDO, D24.SDI
unnamed: D32.SDO, D33.SDI
unnamed: D32.CKO, D33.CKI
unnamed: D25.CKO, D26.CKI
unnamed: D25.SDO, D26.SDI
unnamed: D26.CKO, D27.CKI
unnamed: D26.SDO, D27.SDI
unnamed: D27.CKO, D28.CKI
unnamed: D27.SDO, D28.SDI
unnamed: D28.CKO, D29.CKI
unnamed: D28.SDO, D29.SDI
unnamed: D53.CKO, D54.CKI
unnamed: D53.SDO, D54.SDI
unnamed: D29.CKO, D30.CKI
unnamed: D29.SDO, D30.SDI
unnamed: D30.CKO, D31.CKI
unnamed: D30.SDO, D31.SDI
unnamed: D31.CKO, D32.CKI
unnamed: D31.SDO, D32.SDI
unnamed: D54.CKO, D55.CKI
unnamed: D54.SDO, D55.SDI
unnamed: D33.CKO, D34.CKI
unnamed: D33.SDO, D34.SDI
unnamed: D34.CKO, D35.CKI
unnamed: D34.SDO, D35.SDI
unnamed: D35.CKO, D36.CKI
unnamed: D35.SDO, D36.SDI
unnamed: D36.CKO, D37.CKI
unnamed: D36.SDO, D37.SDI
unnamed: D55.CKO, D56.CKI
unnamed: D55.SDO, D56.SDI
unnamed: D37.CKO, D38.CKI
unnamed: D37.SDO, D38.SDI
unnamed: D38.CKO, D39.CKI
unnamed: D38.SDO, D39.SDI
unnamed: D39.CKO, D40.CKI
unnamed: D39.SDO, D40.SDI
unnamed: D56.CKO, D57.CKI
unnamed: D56.SDO, D57.SDI
unnamed: D42.CKI, D58.CKO
unnamed: D42.SDI, D58.SDO
unnamed: D42.CKO, D43.CKI
unnamed: D42.SDO, D43.SDI
unnamed: D43.CKO, D44.CKI
unnamed: D43.SDO, D44.SDI
unnamed: D8.CKO, D9.CKI
unnamed: D44.CKO, D45.CKI
unnamed: D44.SDO, D45.SDI
unnamed: D45.CKO, D46.CKI
unnamed: D45.SDO, D46.SDI
unnamed: D46.CKO, D47.CKI
unnamed: D46.SDO, D47.SDI
unnamed: D47.CKO, D48.CKI
unnamed: D47.SDO, D48.SDI
unnamed: D49.CKO, D50.CKI
unnamed: D49.SDO, D50.SDI
unnamed: D50.SDO, D59.SDI
unnamed: D59.CKO, D60.CKI
unnamed: D59.SDO, D60.SDI
unnamed: D50.CKO, D59.CKI
unnamed: D60.CKO, D61.CKI
unnamed: D60.SDO, D61.SDI
unnamed: D48.SDO, D49.SDI
unnamed: D48.CKO, D49.CKI
unnamed: D57.SDO, D58.SDI
unnamed: D61.CKO, D62.CKI
unnamed: D61.SDO, D62.SDI
unnamed: D62.CKO, D63.CKI
unnamed: D62.SDO, D63.SDI
unnamed: D63.CKO, D64.CKI
unnamed: D63.SDO, D64.SDI
unnamed: D65.CKO, D66.CKI
unnamed: D65.SDO, D66.SDI
unnamed: D66.CKO, D67.CKI
unnamed: D66.SDO, D67.SDI
unnamed: D67.CKO, D68.CKI
unnamed: D67.SDO, D68.SDI
unnamed: D68.CKO, D69.CKI
unnamed: D68.SDO, D69.SDI
unnamed: D69.CKO, D70.CKI
unnamed: D69.SDO, D70.SDI
unnamed: D70.CKO, D71.CKI
unnamed: D70.SDO, D71.SDI
unnamed: D71.CKO, D72.CKI
unnamed: D71.SDO, D72.SDI
unnamed: D73.CKO, D74.CKI
unnamed: D73.SDO, D74.SDI
unnamed: D74.CKO, D75.CKI
unnamed: D74.SDO, D75.SDI
unnamed: D75.CKO, D76.CKI
unnamed: D75.SDO, D76.SDI
unnamed: D76.CKO, D77.CKI
unnamed: D76.SDO, D77.SDI
unnamed: D77.CKO, D78.CKI
unnamed: D77.SDO, D78.SDI
unnamed: D78.CKO, D79.CKI
unnamed: D78.SDO, D79.SDI
unnamed: D79.CKO, D80.CKI
unnamed: D79.SDO, D80.SDI
unnamed: D57.CKO, D58.CKI
unnamed: D64.CKO, D65.CKI
unnamed: D64.SDO, D65.SDI
unnamed: D72.SDO, D73.SDI
unnamed: D72.CKO, D73.CKI
unnamed: D81.CKO, D91.CKI
unnamed: D81.SDO, D91.SDI
unnamed: D91.CKO, D92.CKI
unnamed: D91.SDO, D92.SDI
unnamed: D92.CKO, D93.CKI
unnamed: D92.SDO, D93.SDI
unnamed: D93.CKO, D94.CKI
unnamed: D93.SDO, D94.SDI
unnamed: D94.CKO, D95.CKI
unnamed: D94.SDO, D95.SDI
unnamed: D95.CKO, D96.CKI
unnamed: D95.SDO, D96.SDI
unnamed: D96.CKO, D97.CKI
unnamed: D96.SDO, D97.SDI
unnamed: D82.CKI, D98.CKO
unnamed: D82.SDI, D98.SDO
unnamed: D82.CKO, D83.CKI
unnamed: D82.SDO, D83.SDI
unnamed: D83.CKO, D84.CKI
unnamed: D83.SDO, D84.SDI
unnamed: D84.CKO, D85.CKI
unnamed: D84.SDO, D85.SDI
unnamed: D85.CKO, D86.CKI
unnamed: D85.SDO, D86.SDI
unnamed: D86.CKO, D87.CKI
unnamed: D86.SDO, D87.SDI
unnamed: D87.CKO, D88.CKI
unnamed: D87.SDO, D88.SDI
unnamed: D89.CKO, D90.CKI
unnamed: D89.SDO, D90.SDI
unnamed: D90.SDO, D99.SDI
unnamed: D99.CKO, D100.CKI
unnamed: D99.SDO, D100.SDI
unnamed: D90.CKO, D99.CKI
unnamed: D100.CKO, D101.CKI
unnamed: D100.SDO, D101.SDI
unnamed: D88.SDO, D89.SDI
unnamed: D88.CKO, D89.CKI
unnamed: D97.SDO, D98.SDI
unnamed: D101.CKO, D102.CKI
unnamed: D101.SDO, D102.SDI
unnamed: D102.CKO, D103.CKI
unnamed: D102.SDO, D103.SDI
unnamed: D103.CKO, D104.CKI
unnamed: D103.SDO, D104.SDI
unnamed: D105.CKO, D106.CKI
unnamed: D105.SDO, D106.SDI
unnamed: D106.CKO, D107.CKI
unnamed: D106.SDO, D107.SDI
unnamed: D107.CKO, D108.CKI
unnamed: D107.SDO, D108.SDI
unnamed: D108.CKO, D109.CKI
unnamed: D108.SDO, D109.SDI
unnamed: D109.CKO, D110.CKI
unnamed: D109.SDO, D110.SDI
unnamed: D110.CKO, D111.CKI
unnamed: D110.SDO, D111.SDI
unnamed: D111.CKO, D112.CKI
unnamed: D111.SDO, D112.SDI
unnamed: D113.CKO, D114.CKI
unnamed: D113.SDO, D114.SDI
unnamed: D114.CKO, D115.CKI
unnamed: D114.SDO, D115.SDI
unnamed: D115.CKO, D116.CKI
unnamed: D115.SDO, D116.SDI
unnamed: D116.CKO, D117.CKI
unnamed: D116.SDO, D117.SDI
unnamed: D117.CKO, D118.CKI
unnamed: D117.SDO, D118.SDI
unnamed: D118.CKO, D119.CKI
unnamed: D118.SDO, D119.SDI
unnamed: D119.CKO, D120.CKI
unnamed: D119.SDO, D120.SDI
unnamed: D97.CKO, D98.CKI
unnamed: D104.CKO, D105.CKI
unnamed: D104.SDO, D105.SDI
unnamed: D112.SDO, D113.SDI
unnamed: D112.CKO, D113.CKI
unnamed: D121.CKO, D131.CKI
unnamed: D121.SDO, D131.SDI
unnamed: D131.CKO, D132.CKI
unnamed: D131.SDO, D132.SDI
unnamed: D132.CKO, D133.CKI
unnamed: D132.SDO, D133.SDI
unnamed: D133.CKO, D134.CKI
unnamed: D133.SDO, D134.SDI
unnamed: D134.CKO, D135.CKI
unnamed: D134.SDO, D135.SDI
unnamed: D135.CKO, D136.CKI
unnamed: D135.SDO, D136.SDI
unnamed: D136.CKO, D137.CKI
unnamed: D136.SDO, D137.SDI
unnamed: D122.CKI, D138.CKO
unnamed: D122.SDI, D138.SDO
unnamed: D122.CKO, D123.CKI
unnamed: D122.SDO, D123.SDI
unnamed: D123.CKO, D124.CKI
unnamed: D123.SDO, D124.SDI
unnamed: D124.CKO, D125.CKI
unnamed: D124.SDO, D125.SDI
unnamed: D125.CKO, D126.CKI
unnamed: D125.SDO, D126.SDI
unnamed: D126.CKO, D127.CKI
unnamed: D126.SDO, D127.SDI
unnamed: D127.CKO, D128.CKI
unnamed: D127.SDO, D128.SDI
unnamed: D129.CKO, D130.CKI
unnamed: D129.SDO, D130.SDI
unnamed: D130.SDO, D139.SDI
unnamed: D139.CKO, D140.CKI
unnamed: D139.SDO, D140.SDI
unnamed: D130.CKO, D139.CKI
unnamed: D140.CKO, D141.CKI
unnamed: D140.SDO, D141.SDI
unnamed: D128.SDO, D129.SDI
unnamed: D128.CKO, D129.CKI
unnamed: D137.SDO, D138.SDI
unnamed: D141.CKO, D142.CKI
unnamed: D141.SDO, D142.SDI
unnamed: D142.CKO, D143.CKI
unnamed: D142.SDO, D143.SDI
unnamed: D143.CKO, D144.CKI
unnamed: D143.SDO, D144.SDI
unnamed: D145.CKO, D146.CKI
unnamed: D145.SDO, D146.SDI
unnamed: D146.CKO, D147.CKI
unnamed: D146.SDO, D147.SDI
unnamed: D147.CKO, D148.CKI
unnamed: D147.SDO, D148.SDI
unnamed: D148.CKO, D149.CKI
unnamed: D148.SDO, D149.SDI
unnamed: D149.CKO, D150.CKI
unnamed: D149.SDO, D150.SDI
unnamed: D150.CKO, D151.CKI
unnamed: D150.SDO, D151.SDI
unnamed: D151.CKO, D152.CKI
unnamed: D151.SDO, D152.SDI
unnamed: D153.CKO, D154.CKI
unnamed: D153.SDO, D154.SDI
unnamed: D154.CKO, D155.CKI
unnamed: D154.SDO, D155.SDI
unnamed: D155.CKO, D156.CKI
unnamed: D155.SDO, D156.SDI
unnamed: D156.CKO, D157.CKI
unnamed: D156.SDO, D157.SDI
unnamed: D157.CKO, D158.CKI
unnamed: D157.SDO, D158.SDI
unnamed: D158.CKO, D159.CKI
unnamed: D158.SDO, D159.SDI
unnamed: D159.CKO, D160.CKI
unnamed: D159.SDO, D160.SDI
unnamed: D137.CKO, D138.CKI
unnamed: D144.CKO, D145.CKI
unnamed: D144.SDO, D145.SDI
unnamed: D152.SDO, D153.SDI
unnamed: D152.CKO, D153.CKI
unnamed: D161.CKO, D171.CKI
unnamed: D161.SDO, D171.SDI
unnamed: D171.CKO, D172.CKI
unnamed: D171.SDO, D172.SDI
unnamed: D172.CKO, D173.CKI
unnamed: D172.SDO, D173.SDI
unnamed: D173.CKO, D174.CKI
unnamed: D173.SDO, D174.SDI
unnamed: D174.CKO, D175.CKI
unnamed: D174.SDO, D175.SDI
unnamed: D175.CKO, D176.CKI
unnamed: D175.SDO, D176.SDI
unnamed: D176.CKO, D177.CKI
unnamed: D176.SDO, D177.SDI
unnamed: D162.CKI, D178.CKO
unnamed: D162.SDI, D178.SDO
unnamed: D162.CKO, D163.CKI
unnamed: D162.SDO, D163.SDI
unnamed: D163.CKO, D164.CKI
unnamed: D163.SDO, D164.SDI
unnamed: D164.CKO, D165.CKI
unnamed: D164.SDO, D165.SDI
unnamed: D165.CKO, D166.CKI
unnamed: D165.SDO, D166.SDI
unnamed: D166.CKO, D167.CKI
unnamed: D166.SDO, D167.SDI
unnamed: D167.CKO, D168.CKI
unnamed: D167.SDO, D168.SDI
unnamed: D169.CKO, D170.CKI
unnamed: D169.SDO, D170.SDI
unnamed: D170.SDO, D179.SDI
unnamed: D179.CKO, D180.CKI
unnamed: D179.SDO, D180.SDI
unnamed: D170.CKO, D179.CKI
unnamed: D180.CKO, D181.CKI
unnamed: D180.SDO, D181.SDI
unnamed: D168.SDO, D169.SDI
unnamed: D168.CKO, D169.CKI
unnamed: D177.SDO, D178.SDI
unnamed: D181.CKO, D182.CKI
unnamed: D181.SDO, D182.SDI
unnamed: D182.CKO, D183.CKI
unnamed: D182.SDO, D183.SDI
unnamed: D183.CKO, D184.CKI
unnamed: D183.SDO, D184.SDI
unnamed: D185.CKO, D186.CKI
unnamed: D185.SDO, D186.SDI
unnamed: D186.CKO, D187.CKI
unnamed: D186.SDO, D187.SDI
unnamed: D187.CKO, D188.CKI
unnamed: D187.SDO, D188.SDI
unnamed: D188.CKO, D189.CKI
unnamed: D188.SDO, D189.SDI
unnamed: D189.CKO, D190.CKI
unnamed: D189.SDO, D190.SDI
unnamed: D190.CKO, D191.CKI
unnamed: D190.SDO, D191.SDI
unnamed: D191.CKO, D192.CKI
unnamed: D191.SDO, D192.SDI
unnamed: D193.CKO, D194.CKI
unnamed: D193.SDO, D194.SDI
unnamed: D194.CKO, D195.CKI
unnamed: D194.SDO, D195.SDI
unnamed: D195.CKO, D196.CKI
unnamed: D195.SDO, D196.SDI
unnamed: D196.CKO, D197.CKI
unnamed: D196.SDO, D197.SDI
unnamed: D197.CKO, D198.CKI
unnamed: D197.SDO, D198.SDI
unnamed: D198.CKO, D199.CKI
unnamed: D198.SDO, D199.SDI
unnamed: D199.CKO, D200.CKI
unnamed: D199.SDO, D200.SDI
unnamed: D177.CKO, D178.CKI
unnamed: D184.CKO, D185.CKI
unnamed: D184.SDO, D185.SDI
unnamed: D192.SDO, D193.SDI
unnamed: D192.CKO, D193.CKI
unnamed: D201.CKO, D211.CKI
unnamed: D201.SDO, D211.SDI
unnamed: D211.CKO, D212.CKI
unnamed: D211.SDO, D212.SDI
unnamed: D212.CKO, D213.CKI
unnamed: D212.SDO, D213.SDI
unnamed: D213.CKO, D214.CKI
unnamed: D213.SDO, D214.SDI
unnamed: D214.CKO, D215.CKI
unnamed: D214.SDO, D215.SDI
unnamed: D215.CKO, D216.CKI
unnamed: D215.SDO, D216.SDI
unnamed: D216.CKO, D217.CKI
unnamed: D216.SDO, D217.SDI
unnamed: D202.CKI, D218.CKO
unnamed: D202.SDI, D218.SDO
unnamed: D202.CKO, D203.CKI
unnamed: D202.SDO, D203.SDI
unnamed: D203.CKO, D204.CKI
unnamed: D203.SDO, D204.SDI
unnamed: D204.CKO, D205.CKI
unnamed: D204.SDO, D205.SDI
unnamed: D205.CKO, D206.CKI
unnamed: D205.SDO, D206.SDI
unnamed: D206.CKO, D207.CKI
unnamed: D206.SDO, D207.SDI
unnamed: D207.CKO, D208.CKI
unnamed: D207.SDO, D208.SDI
unnamed: D209.CKO, D210.CKI
unnamed: D209.SDO, D210.SDI
unnamed: D210.SDO, D219.SDI
unnamed: D219.CKO, D220.CKI
unnamed: D219.SDO, D220.SDI
unnamed: D210.CKO, D219.CKI
unnamed: D220.CKO, D221.CKI
unnamed: D220.SDO, D221.SDI
unnamed: D208.SDO, D209.SDI
unnamed: D208.CKO, D209.CKI
unnamed: D217.SDO, D218.SDI
unnamed: D221.CKO, D222.CKI
unnamed: D221.SDO, D222.SDI
unnamed: D222.CKO, D223.CKI
unnamed: D222.SDO, D223.SDI
unnamed: D223.CKO, D224.CKI
unnamed: D223.SDO, D224.SDI
unnamed: D225.CKO, D226.CKI
unnamed: D225.SDO, D226.SDI
unnamed: D226.CKO, D227.CKI
unnamed: D226.SDO, D227.SDI
unnamed: D227.CKO, D228.CKI
unnamed: D227.SDO, D228.SDI
unnamed: D228.CKO, D229.CKI
unnamed: D228.SDO, D229.SDI
unnamed: D229.CKO, D230.CKI
unnamed: D229.SDO, D230.SDI
unnamed: D230.CKO, D231.CKI
unnamed: D230.SDO, D231.SDI
unnamed: D231.CKO, D232.CKI
unnamed: D231.SDO, D232.SDI
unnamed: D233.CKO, D234.CKI
unnamed: D233.SDO, D234.SDI
unnamed: D234.CKO, D235.CKI
unnamed: D234.SDO, D235.SDI
unnamed: D235.CKO, D236.CKI
unnamed: D235.SDO, D236.SDI
unnamed: D236.CKO, D237.CKI
unnamed: D236.SDO, D237.SDI
unnamed: D237.CKO, D238.CKI
unnamed: D237.SDO, D238.SDI
unnamed: D238.CKO, D239.CKI
unnamed: D238.SDO, D239.SDI
unnamed: D239.CKO, D240.CKI
unnamed: D239.SDO, D240.SDI
unnamed: D217.CKO, D218.CKI
unnamed: D224.CKO, D225.CKI
unnamed: D224.SDO, D225.SDI
unnamed: D232.SDO, D233.SDI
unnamed: D232.CKO, D233.CKI
unnamed: D241.CKO, D251.CKI
unnamed: D241.SDO, D251.SDI
unnamed: D251.CKO, D252.CKI
unnamed: D251.SDO, D252.SDI
unnamed: D252.CKO, D253.CKI
unnamed: D252.SDO, D253.SDI
unnamed: D253.CKO, D254.CKI
unnamed: D253.SDO, D254.SDI
unnamed: D254.CKO, D255.CKI
unnamed: D254.SDO, D255.SDI
unnamed: D255.CKO, D256.CKI
unnamed: D255.SDO, D256.SDI
unnamed: D256.CKO, D257.CKI
unnamed: D256.SDO, D257.SDI
unnamed: D242.CKI, D258.CKO
unnamed: D242.SDI, D258.SDO
unnamed: D242.CKO, D243.CKI
unnamed: D242.SDO, D243.SDI
unnamed: D243.CKO, D244.CKI
unnamed: D243.SDO, D244.SDI
unnamed: D244.CKO, D245.CKI
unnamed: D244.SDO, D245.SDI
unnamed: D245.CKO, D246.CKI
unnamed: D245.SDO, D246.SDI
unnamed: D246.CKO, D247.CKI
unnamed: D246.SDO, D247.SDI
unnamed: D247.CKO, D248.CKI
unnamed: D247.SDO, D248.SDI
unnamed: D249.CKO, D250.CKI
unnamed: D249.SDO, D250.SDI
unnamed: D250.SDO, D259.SDI
unnamed: D259.CKO, D260.CKI
unnamed: D259.SDO, D260.SDI
unnamed: D250.CKO, D259.CKI
unnamed: D260.CKO, D261.CKI
unnamed: D260.SDO, D261.SDI
unnamed: D248.SDO, D249.SDI
unnamed: D248.CKO, D249.CKI
unnamed: D257.SDO, D258.SDI
unnamed: D261.CKO, D262.CKI
unnamed: D261.SDO, D262.SDI
unnamed: D262.CKO, D263.CKI
unnamed: D262.SDO, D263.SDI
unnamed: D263.CKO, D264.CKI
unnamed: D263.SDO, D264.SDI
unnamed: D265.CKO, D266.CKI
unnamed: D265.SDO, D266.SDI
unnamed: D266.CKO, D267.CKI
unnamed: D266.SDO, D267.SDI
unnamed: D267.CKO, D268.CKI
unnamed: D267.SDO, D268.SDI
unnamed: D268.CKO, D269.CKI
unnamed: D268.SDO, D269.SDI
unnamed: D269.CKO, D270.CKI
unnamed: D269.SDO, D270.SDI
unnamed: D270.CKO, D271.CKI
unnamed: D270.SDO, D271.SDI
unnamed: D271.CKO, D272.CKI
unnamed: D271.SDO, D272.SDI
unnamed: D273.CKO, D274.CKI
unnamed: D273.SDO, D274.SDI
unnamed: D274.CKO, D275.CKI
unnamed: D274.SDO, D275.SDI
unnamed: D275.CKO, D276.CKI
unnamed: D275.SDO, D276.SDI
unnamed: D276.CKO, D277.CKI
unnamed: D276.SDO, D277.SDI
unnamed: D277.CKO, D278.CKI
unnamed: D277.SDO, D278.SDI
unnamed: D278.CKO, D279.CKI
unnamed: D278.SDO, D279.SDI
unnamed: D279.CKO, D280.CKI
unnamed: D279.SDO, D280.SDI
unnamed: D257.CKO, D258.CKI
unnamed: D264.CKO, D265.CKI
unnamed: D264.SDO, D265.SDI
unnamed: D272.SDO, D273.SDI
unnamed: D272.CKO, D273.CKI
unnamed: D281.CKO, D291.CKI
unnamed: D281.SDO, D291.SDI
unnamed: D291.CKO, D292.CKI
unnamed: D291.SDO, D292.SDI
unnamed: D292.CKO, D293.CKI
unnamed: D292.SDO, D293.SDI
unnamed: D293.CKO, D294.CKI
unnamed: D293.SDO, D294.SDI
unnamed: D294.CKO, D295.CKI
unnamed: D294.SDO, D295.SDI
unnamed: D295.CKO, D296.CKI
unnamed: D295.SDO, D296.SDI
unnamed: D296.CKO, D297.CKI
unnamed: D296.SDO, D297.SDI
unnamed: D282.CKI, D298.CKO
unnamed: D282.SDI, D298.SDO
unnamed: D282.CKO, D283.CKI
unnamed: D282.SDO, D283.SDI
unnamed: D283.CKO, D284.CKI
unnamed: D283.SDO, D284.SDI
unnamed: D284.CKO, D285.CKI
unnamed: D284.SDO, D285.SDI
unnamed: D285.CKO, D286.CKI
unnamed: D285.SDO, D286.SDI
unnamed: D286.CKO, D287.CKI
unnamed: D286.SDO, D287.SDI
unnamed: D287.CKO, D288.CKI
unnamed: D287.SDO, D288.SDI
unnamed: D289.CKO, D290.CKI
unnamed: D289.SDO, D290.SDI
unnamed: D290.SDO, D299.SDI
unnamed: D299.CKO, D300.CKI
unnamed: D299.SDO, D300.SDI
unnamed: D290.CKO, D299.CKI
unnamed: D300.CKO, D301.CKI
unnamed: D300.SDO, D301.SDI
unnamed: D288.SDO, D289.SDI
unnamed: D288.CKO, D289.CKI
unnamed: D297.SDO, D298.SDI
unnamed: D301.CKO, D302.CKI
unnamed: D301.SDO, D302.SDI
unnamed: D302.CKO, D303.CKI
unnamed: D302.SDO, D303.SDI
unnamed: D303.CKO, D304.CKI
unnamed: D303.SDO, D304.SDI
unnamed: D305.CKO, D306.CKI
unnamed: D305.SDO, D306.SDI
unnamed: D306.CKO, D307.CKI
unnamed: D306.SDO, D307.SDI
unnamed: D307.CKO, D308.CKI
unnamed: D307.SDO, D308.SDI
unnamed: D308.CKO, D309.CKI
unnamed: D308.SDO, D309.SDI
unnamed: D309.CKO, D310.CKI
unnamed: D309.SDO, D310.SDI
unnamed: D310.CKO, D311.CKI
unnamed: D310.SDO, D311.SDI
unnamed: D311.CKO, D312.CKI
unnamed: D311.SDO, D312.SDI
unnamed: D313.CKO, D314.CKI
unnamed: D313.SDO, D314.SDI
unnamed: D314.CKO, D315.CKI
unnamed: D314.SDO, D315.SDI
unnamed: D315.CKO, D316.CKI
unnamed: D315.SDO, D316.SDI
unnamed: D316.CKO, D317.CKI
unnamed: D316.SDO, D317.SDI
unnamed: D317.CKO, D318.CKI
unnamed: D317.SDO, D318.SDI
unnamed: D318.CKO, D319.CKI
unnamed: D318.SDO, D319.SDI
unnamed: D319.CKO, D320.CKI
unnamed: D319.SDO, D320.SDI
unnamed: D297.CKO, D298.CKI
unnamed: D304.CKO, D305.CKI
unnamed: D304.SDO, D305.SDI
unnamed: D312.SDO, D313.SDI
unnamed: D312.CKO, D313.CKI

## Commit log

2018-10-12 adding silk
2018-10-15 post checklist
2018-10-22 cleaning schematic
2018-12-03 Updating to proper footprint
2018-12-06 version number change
2018-12-07 panel
2019-01-17 cleaning repo, adding readme
2019-06-05 adding gnd via
2020-01-09 updating gnd vias

Notices in the files:
parts and their libraries:
SparkFun-LED: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
